#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"

unsigned char code Animation[] =  // Place in Flash, cannot be changed
{
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0xFF,0x80,0x80,0xFF,0x01,0x01,0xFF,0x00,0x9F,0x99,0x99,0x99,0x99,0xF9,0x00,0xFF,
0xA5,0xA5,0xA5,0xFF,0x00,0xFF,0x18,0x18,0x18,0x7E,0x7E,0x18,0x18,0x18,0xFF,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
};

void main()
{
	unsigned char i, Offset = 1, Count = 0;
	MatrixLED_Init();
	while(1)
	{
		for (i = 0; i < 8; i ++)
		{
			MatrixLED_ShowColumn(i, Animation[i + Offset]);
		}
		
		// Use this as delay
		Count ++;
		if (Count > 10)
		{
			Count = 0;
			Offset ++; // +8 when want instant change
			if (Offset > 40)
				Offset = 0;
		}
	}
}
